# Keil uVision project AC_sim.uvproj, settings and files
target STM32F4_Discovery (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: AC_sim
  c flags: Optim=1
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: .\Files_Project;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\ST\STM32F4_Discovery;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./Files_Project/: main.c debug_cmd.c Peripheral_Config.c stm32f4xx_it.c strtod.c
  group Libs
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c
  group MKD-ARM
    ../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group CMSIS
    ../Libraries/CMSIS/ST/STM32F4_Discovery/: system_stm32f4xx.c
